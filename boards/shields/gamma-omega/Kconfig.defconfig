## boards/shields/gamma-omega/Kconfig.defconfig
```kconfig
if SHIELD_GAMMA_OMEGA

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "GAMMA OMEGA"


endif
```
